# Placeholder until we have a real eMagii license

LICENSE = "CLOSED"
